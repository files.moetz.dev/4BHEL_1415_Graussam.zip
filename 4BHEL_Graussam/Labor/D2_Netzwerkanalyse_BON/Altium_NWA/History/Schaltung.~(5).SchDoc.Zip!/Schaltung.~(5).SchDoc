# Altium schematic sheet Schaltung.~(5).SchDoc
size A4

## Notes on the sheet
- Switch
- Dut