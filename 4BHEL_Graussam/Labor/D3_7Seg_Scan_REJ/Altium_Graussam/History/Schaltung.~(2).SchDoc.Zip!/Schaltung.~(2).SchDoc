# Altium schematic sheet Schaltung.~(2).SchDoc
size A4

## Notes on the sheet
- a
- b
- f
- c
- d
- e
- g
- COM